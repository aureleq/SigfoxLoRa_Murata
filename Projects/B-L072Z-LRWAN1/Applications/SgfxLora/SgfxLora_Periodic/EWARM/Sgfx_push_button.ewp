# IAR project Sgfx_push_button.ewp, settings and files
configuration mlm32l07x01 (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CZ ST STM32L072CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L072xx; USE_B_L072Z_LRWAN1; USE_FULL_LL_DRIVER; USE_RADIO_LL_DRIVER
  ICCARM.CCIncludePath2: ../inc; ../../../../../../Drivers/BSP/MLM32L07X01; ../../../../../../Drivers/BSP/Components/sx1276; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/B-L072Z-LRWAN1; ../../../../../../Middlewares/Third_Party/Sgfx/utils; ../../../../../../Middlewares/Third_Party/Sgfx/SigfoxLib; ../../../../../../Middlewares/Third_Party/Sgfx/SigfoxLibTest; ../../../../../../Middlewares/Third_Party/Sgfx/Crypto; ../../../../../../Drivers/BSP/Components; ..\..\Common\cwmx1zzabz\Radio_Sigfox_Driver; ../../../../../../Drivers/BSP/Components/hts221; ../../../../../../Drivers/BSP/Components/lps22hb; ../../../../../../Drivers/BSP/Components/lps25hb; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2; ..\..\Common\cwmx1zzabz\Credentials_libs
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sgfx_push_button.bin
  ILINK.IlinkOutputFile: DISCO_CUBE_SGFX_WLIB.out
  ILINK.IlinkIcfFile: stm32l072xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L072Z-LRWAN1
    ../../../../../../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
  group Drivers/BSP/MLM32L0X01
    ../../../../../../Drivers/BSP/MLM32L07X01/: mlm32l07x01.c
    ../../../../../../Drivers/BSP/Components/sx1276/: sx1276.c
  group Drivers/BSP/X_NUCLEO_IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Source/Templates/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_ll_dma.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_rcc.c
  group Middlewares/Crypto
    ../../../../../../Middlewares/Third_Party/Sgfx/Crypto/: se_nvm.c SgfxCmacV100_CM0_IAR_O3.a sigfox_data.c
  group Middlewares/Lib
    ../../../../../../Middlewares/Third_Party/Sgfx/SigfoxLibTest/: SgfxAddonV020_CM0_IAR.a
    ../../../../../../Middlewares/Third_Party/Sgfx/SigfoxLib/: SgfxCoreV231_CM0_IAR.a
  group Middlewares/Utilities
    ../../../../../../Middlewares/Third_Party/Sgfx/utils/: low_power_manager.c scheduler.c timeServer.c utilities.c
  group Projects/IAR
    ./: startup_stm32l072xx.s
  group Projects/Sgfx_push_button
    ../src/: bsp.c debug.c hw_eeprom.c hw_gpio.c hw_rtc.c hw_spi.c hw_tim2.c main.c mlm32l0xx_hal_msp.c mlm32l0xx_hw.c mlm32l0xx_it.c tiny_sscanf.c tiny_vsnprintf.c vcom.c
    ../../Common/cwmx1zzabz/Radio_Sigfox_Driver/: mcu_api.c rf_api.c SgfxSTModemSx1276V123_CM0_IAR_O3.a st_lowlevel.c
    ../../Common/cwmx1zzabz/Credentials_libs/: SgfxCredentialsV011_CM0_IAR_O3.a
